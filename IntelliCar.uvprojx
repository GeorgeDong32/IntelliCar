# Keil uVision project IntelliCar.uvprojx, settings and files
target IntelliCar (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntelliCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\HARDWARE;.\FWLIB\inc;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: delay.c main.c stm32f10x_it.c
  group HARDWARE
    ./HARDWARE/: IRAvoid.c IRSEARCH.c Motor.c Servo.c timer.c sys.c keysacn.c UltrasonicWave.c usart.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
